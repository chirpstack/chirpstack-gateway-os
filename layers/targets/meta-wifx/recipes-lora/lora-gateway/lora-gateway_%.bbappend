SRC_URI_append = " \
    file://wifx.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
