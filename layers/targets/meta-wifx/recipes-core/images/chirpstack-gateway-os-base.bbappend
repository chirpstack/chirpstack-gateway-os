IMAGE_INSTALL += " \
    packagegroup-base-usbgadget \
    kernel-modules \
    gateway-config \
"

