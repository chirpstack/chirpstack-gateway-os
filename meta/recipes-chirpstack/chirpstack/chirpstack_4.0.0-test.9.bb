# Auto-Generated by cargo-bitbake 0.3.16
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get chirpstack could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/chirpstack/4.0.0-test.9"
SRC_URI += "git://git@github.com/chirpstack/chirpstack.git;protocol=ssh;nobranch=1"
SRCREV = "9db867906d4a0bb092ed9e891fd9e83c6895b010"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = "chirpstack"


# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
    crate://crates.io/aes-kw/0.2.1 \
    crate://crates.io/aes/0.7.5 \
    crate://crates.io/aes/0.8.1 \
    crate://crates.io/aho-corasick/0.7.18 \
    crate://crates.io/amq-protocol-tcp/7.0.1 \
    crate://crates.io/amq-protocol-types/7.0.1 \
    crate://crates.io/amq-protocol-uri/7.0.1 \
    crate://crates.io/amq-protocol/7.0.1 \
    crate://crates.io/ansi_term/0.12.1 \
    crate://crates.io/anyhow/1.0.58 \
    crate://crates.io/ascii-canvas/3.0.0 \
    crate://crates.io/assert-json-diff/2.0.2 \
    crate://crates.io/async-channel/1.6.1 \
    crate://crates.io/async-executor/1.4.1 \
    crate://crates.io/async-global-executor-trait/2.1.0 \
    crate://crates.io/async-global-executor/2.2.0 \
    crate://crates.io/async-io/1.7.0 \
    crate://crates.io/async-lock/2.5.0 \
    crate://crates.io/async-object-pool/0.1.4 \
    crate://crates.io/async-process/1.4.0 \
    crate://crates.io/async-reactor-trait/1.1.0 \
    crate://crates.io/async-recursion/1.0.0 \
    crate://crates.io/async-std/1.12.0 \
    crate://crates.io/async-stream-impl/0.3.3 \
    crate://crates.io/async-stream/0.3.3 \
    crate://crates.io/async-task/4.3.0 \
    crate://crates.io/async-trait/0.1.56 \
    crate://crates.io/atomic-waker/1.0.0 \
    crate://crates.io/atty/0.2.14 \
    crate://crates.io/autocfg/1.1.0 \
    crate://crates.io/aws-config/0.3.0 \
    crate://crates.io/aws-endpoint/0.3.0 \
    crate://crates.io/aws-http/0.3.0 \
    crate://crates.io/aws-sdk-sns/0.3.0 \
    crate://crates.io/aws-sdk-sts/0.3.0 \
    crate://crates.io/aws-sig-auth/0.3.0 \
    crate://crates.io/aws-sigv4/0.3.0 \
    crate://crates.io/aws-smithy-async/0.33.1 \
    crate://crates.io/aws-smithy-client/0.33.1 \
    crate://crates.io/aws-smithy-http-tower/0.33.1 \
    crate://crates.io/aws-smithy-http/0.33.1 \
    crate://crates.io/aws-smithy-json/0.33.1 \
    crate://crates.io/aws-smithy-query/0.33.1 \
    crate://crates.io/aws-smithy-types/0.33.1 \
    crate://crates.io/aws-smithy-xml/0.33.1 \
    crate://crates.io/aws-types/0.3.0 \
    crate://crates.io/axum-core/0.2.7 \
    crate://crates.io/axum/0.5.13 \
    crate://crates.io/base64/0.13.0 \
    crate://crates.io/base64ct/1.5.1 \
    crate://crates.io/basic-cookies/0.1.4 \
    crate://crates.io/bigdecimal/0.3.0 \
    crate://crates.io/bindgen/0.60.1 \
    crate://crates.io/bit-set/0.5.2 \
    crate://crates.io/bit-vec/0.6.3 \
    crate://crates.io/bitflags/1.3.2 \
    crate://crates.io/block-buffer/0.10.2 \
    crate://crates.io/block-buffer/0.7.3 \
    crate://crates.io/block-buffer/0.9.0 \
    crate://crates.io/block-padding/0.1.5 \
    crate://crates.io/block-padding/0.3.2 \
    crate://crates.io/blocking/1.2.0 \
    crate://crates.io/buf_redux/0.8.4 \
    crate://crates.io/bumpalo/3.10.0 \
    crate://crates.io/byte-tools/0.3.1 \
    crate://crates.io/byteorder/1.4.3 \
    crate://crates.io/bytes-utils/0.1.2 \
    crate://crates.io/bytes/1.2.0 \
    crate://crates.io/cache-padded/1.2.0 \
    crate://crates.io/castaway/0.1.2 \
    crate://crates.io/cbc/0.1.2 \
    crate://crates.io/cc/1.0.73 \
    crate://crates.io/cexpr/0.6.0 \
    crate://crates.io/cfg-if/1.0.0 \
    crate://crates.io/chrono/0.4.19 \
    crate://crates.io/cipher/0.3.0 \
    crate://crates.io/cipher/0.4.3 \
    crate://crates.io/clang-sys/1.3.3 \
    crate://crates.io/clap/2.34.0 \
    crate://crates.io/clap/3.2.12 \
    crate://crates.io/clap_lex/0.2.4 \
    crate://crates.io/cmac/0.6.0 \
    crate://crates.io/cmake/0.1.48 \
    crate://crates.io/combine/4.6.4 \
    crate://crates.io/concurrent-queue/1.2.3 \
    crate://crates.io/cookie-factory/0.3.2 \
    crate://crates.io/core-foundation-sys/0.8.3 \
    crate://crates.io/core-foundation/0.9.3 \
    crate://crates.io/cpufeatures/0.2.2 \
    crate://crates.io/crc16/0.4.0 \
    crate://crates.io/crossbeam-utils/0.8.10 \
    crate://crates.io/crunchy/0.2.2 \
    crate://crates.io/crypto-common/0.1.6 \
    crate://crates.io/crypto-mac/0.11.1 \
    crate://crates.io/ct-logs/0.8.0 \
    crate://crates.io/ctor/0.1.22 \
    crate://crates.io/curl-sys/0.4.55+curl-7.83.1 \
    crate://crates.io/curl/0.4.43 \
    crate://crates.io/dbl/0.3.2 \
    crate://crates.io/des/0.8.1 \
    crate://crates.io/diesel/2.0.0-rc.0 \
    crate://crates.io/diesel_derives/2.0.0-rc.0 \
    crate://crates.io/diesel_migrations/2.0.0-rc.0 \
    crate://crates.io/diff/0.1.13 \
    crate://crates.io/digest/0.10.3 \
    crate://crates.io/digest/0.8.1 \
    crate://crates.io/digest/0.9.0 \
    crate://crates.io/dirs-next/2.0.0 \
    crate://crates.io/dirs-sys-next/0.1.2 \
    crate://crates.io/doc-comment/0.3.3 \
    crate://crates.io/dtoa/0.4.8 \
    crate://crates.io/dtoa/1.0.2 \
    crate://crates.io/either/1.7.0 \
    crate://crates.io/ena/0.14.0 \
    crate://crates.io/encoding_rs/0.8.31 \
    crate://crates.io/env_logger/0.9.0 \
    crate://crates.io/event-listener/2.5.2 \
    crate://crates.io/executor-trait/2.1.0 \
    crate://crates.io/fake-simd/0.1.2 \
    crate://crates.io/fastrand/1.7.0 \
    crate://crates.io/fixedbitset/0.4.2 \
    crate://crates.io/flume/0.10.13 \
    crate://crates.io/fnv/1.0.7 \
    crate://crates.io/foreign-types-shared/0.1.1 \
    crate://crates.io/foreign-types/0.3.2 \
    crate://crates.io/form_urlencoded/1.0.1 \
    crate://crates.io/futures-channel/0.3.21 \
    crate://crates.io/futures-core/0.3.21 \
    crate://crates.io/futures-executor/0.3.21 \
    crate://crates.io/futures-io/0.3.21 \
    crate://crates.io/futures-lite/1.12.0 \
    crate://crates.io/futures-macro/0.3.21 \
    crate://crates.io/futures-sink/0.3.21 \
    crate://crates.io/futures-task/0.3.21 \
    crate://crates.io/futures-timer/3.0.2 \
    crate://crates.io/futures-util/0.3.21 \
    crate://crates.io/futures/0.3.21 \
    crate://crates.io/gcp_auth/0.7.3 \
    crate://crates.io/generic-array/0.12.4 \
    crate://crates.io/generic-array/0.14.5 \
    crate://crates.io/geo-types/0.7.6 \
    crate://crates.io/geohash/0.12.0 \
    crate://crates.io/getrandom/0.2.7 \
    crate://crates.io/glob/0.3.0 \
    crate://crates.io/gloo-timers/0.2.4 \
    crate://crates.io/h2/0.3.13 \
    crate://crates.io/handlebars/4.3.2 \
    crate://crates.io/hashbrown/0.12.3 \
    crate://crates.io/headers-core/0.2.0 \
    crate://crates.io/headers/0.3.7 \
    crate://crates.io/heck/0.4.0 \
    crate://crates.io/hermit-abi/0.1.19 \
    crate://crates.io/hex/0.4.3 \
    crate://crates.io/hmac/0.11.0 \
    crate://crates.io/hmac/0.12.1 \
    crate://crates.io/http-body/0.4.5 \
    crate://crates.io/http-range-header/0.3.0 \
    crate://crates.io/http/0.2.8 \
    crate://crates.io/httparse/1.7.1 \
    crate://crates.io/httpdate/1.0.2 \
    crate://crates.io/httpmock/0.6.6 \
    crate://crates.io/humantime-serde/1.1.1 \
    crate://crates.io/humantime/2.1.0 \
    crate://crates.io/hyper-rustls/0.22.1 \
    crate://crates.io/hyper-rustls/0.23.0 \
    crate://crates.io/hyper-timeout/0.4.1 \
    crate://crates.io/hyper-tls/0.5.0 \
    crate://crates.io/hyper/0.14.20 \
    crate://crates.io/idna/0.2.3 \
    crate://crates.io/indexmap/1.9.1 \
    crate://crates.io/inout/0.1.3 \
    crate://crates.io/instant/0.1.12 \
    crate://crates.io/ipnet/2.5.0 \
    crate://crates.io/isahc/1.7.2 \
    crate://crates.io/itertools/0.10.3 \
    crate://crates.io/itoa/0.4.8 \
    crate://crates.io/itoa/1.0.2 \
    crate://crates.io/js-sys/0.3.58 \
    crate://crates.io/jsonwebtoken/8.1.1 \
    crate://crates.io/kv-log-macro/1.0.7 \
    crate://crates.io/lalrpop-util/0.19.8 \
    crate://crates.io/lalrpop/0.19.8 \
    crate://crates.io/lapin/2.1.1 \
    crate://crates.io/lazy_static/1.4.0 \
    crate://crates.io/lazycell/1.3.0 \
    crate://crates.io/levenshtein/1.0.5 \
    crate://crates.io/libc/0.2.126 \
    crate://crates.io/libloading/0.7.3 \
    crate://crates.io/libm/0.2.2 \
    crate://crates.io/libnghttp2-sys/0.1.7+1.45.0 \
    crate://crates.io/libz-sys/1.1.8 \
    crate://crates.io/linked-hash-map/0.5.6 \
    crate://crates.io/lock_api/0.4.7 \
    crate://crates.io/log/0.4.17 \
    crate://crates.io/maplit/1.0.2 \
    crate://crates.io/matchers/0.0.1 \
    crate://crates.io/matches/0.1.9 \
    crate://crates.io/matchit/0.5.0 \
    crate://crates.io/memchr/2.5.0 \
    crate://crates.io/migrations_internals/2.0.0-rc.0 \
    crate://crates.io/migrations_macros/2.0.0-rc.0 \
    crate://crates.io/mime/0.3.16 \
    crate://crates.io/mime_guess/2.0.4 \
    crate://crates.io/minimal-lexical/0.2.1 \
    crate://crates.io/mio/0.8.4 \
    crate://crates.io/multimap/0.8.3 \
    crate://crates.io/multipart/0.18.0 \
    crate://crates.io/native-tls/0.2.10 \
    crate://crates.io/new_debug_unreachable/1.0.4 \
    crate://crates.io/nom/7.1.1 \
    crate://crates.io/num-bigint/0.4.3 \
    crate://crates.io/num-integer/0.1.45 \
    crate://crates.io/num-traits/0.2.15 \
    crate://crates.io/num_cpus/1.13.1 \
    crate://crates.io/num_enum/0.5.7 \
    crate://crates.io/num_enum_derive/0.5.7 \
    crate://crates.io/num_threads/0.1.6 \
    crate://crates.io/oauth2/4.2.3 \
    crate://crates.io/once_cell/1.13.0 \
    crate://crates.io/opaque-debug/0.2.3 \
    crate://crates.io/opaque-debug/0.3.0 \
    crate://crates.io/openidconnect/2.3.2 \
    crate://crates.io/openssl-macros/0.1.0 \
    crate://crates.io/openssl-probe/0.1.5 \
    crate://crates.io/openssl-src/111.22.0+1.1.1q \
    crate://crates.io/openssl-sys/0.9.75 \
    crate://crates.io/openssl/0.10.41 \
    crate://crates.io/ordered-float/2.10.0 \
    crate://crates.io/os_str_bytes/6.2.0 \
    crate://crates.io/owning_ref/0.4.1 \
    crate://crates.io/p12/0.6.3 \
    crate://crates.io/paho-mqtt-sys/0.5.0 \
    crate://crates.io/paho-mqtt/0.9.1 \
    crate://crates.io/parking/2.0.0 \
    crate://crates.io/parking_lot/0.12.1 \
    crate://crates.io/parking_lot_core/0.9.3 \
    crate://crates.io/password-hash/0.2.3 \
    crate://crates.io/pbjson-build/0.3.2 \
    crate://crates.io/pbjson-types/0.3.2 \
    crate://crates.io/pbjson/0.3.2 \
    crate://crates.io/pbkdf2/0.8.0 \
    crate://crates.io/peeking_take_while/0.1.2 \
    crate://crates.io/pem/1.1.0 \
    crate://crates.io/percent-encoding/2.1.0 \
    crate://crates.io/pest/2.1.3 \
    crate://crates.io/pest_derive/2.1.0 \
    crate://crates.io/pest_generator/2.1.3 \
    crate://crates.io/pest_meta/2.1.3 \
    crate://crates.io/petgraph/0.6.2 \
    crate://crates.io/phf_shared/0.10.0 \
    crate://crates.io/pico-args/0.4.2 \
    crate://crates.io/pin-project-internal/1.0.11 \
    crate://crates.io/pin-project-lite/0.2.9 \
    crate://crates.io/pin-project/1.0.11 \
    crate://crates.io/pin-utils/0.1.0 \
    crate://crates.io/pinky-swear/6.1.0 \
    crate://crates.io/pkg-config/0.3.25 \
    crate://crates.io/polling/2.2.0 \
    crate://crates.io/ppv-lite86/0.2.16 \
    crate://crates.io/pq-sys/0.4.7 \
    crate://crates.io/precomputed-hash/0.1.1 \
    crate://crates.io/prettyplease/0.1.16 \
    crate://crates.io/proc-macro-crate/1.1.3 \
    crate://crates.io/proc-macro-error-attr/1.0.4 \
    crate://crates.io/proc-macro-error/1.0.4 \
    crate://crates.io/proc-macro2/1.0.40 \
    crate://crates.io/prometheus-client-derive-text-encode/0.2.0 \
    crate://crates.io/prometheus-client/0.16.0 \
    crate://crates.io/prost-build/0.10.4 \
    crate://crates.io/prost-derive/0.10.1 \
    crate://crates.io/prost-types/0.10.1 \
    crate://crates.io/prost/0.10.4 \
    crate://crates.io/quick-error/1.2.3 \
    crate://crates.io/quote/1.0.20 \
    crate://crates.io/r2d2/0.8.10 \
    crate://crates.io/rand/0.8.5 \
    crate://crates.io/rand_chacha/0.3.1 \
    crate://crates.io/rand_core/0.6.3 \
    crate://crates.io/rc2/0.8.1 \
    crate://crates.io/rdkafka-sys/4.2.0+1.8.2 \
    crate://crates.io/rdkafka/0.28.0 \
    crate://crates.io/reactor-trait/1.1.0 \
    crate://crates.io/redis/0.21.5 \
    crate://crates.io/redox_syscall/0.2.13 \
    crate://crates.io/redox_users/0.4.3 \
    crate://crates.io/regex-automata/0.1.10 \
    crate://crates.io/regex-syntax/0.6.27 \
    crate://crates.io/regex/1.6.0 \
    crate://crates.io/relative-path/1.7.2 \
    crate://crates.io/remove_dir_all/0.5.3 \
    crate://crates.io/reqwest/0.11.11 \
    crate://crates.io/ring/0.16.20 \
    crate://crates.io/rquickjs-core/0.1.6 \
    crate://crates.io/rquickjs-sys/0.1.6 \
    crate://crates.io/rquickjs/0.1.6 \
    crate://crates.io/rust-embed-impl/6.2.0 \
    crate://crates.io/rust-embed-utils/7.2.0 \
    crate://crates.io/rust-embed/6.4.0 \
    crate://crates.io/rustc-hash/1.1.0 \
    crate://crates.io/rustc_version/0.4.0 \
    crate://crates.io/rustls-connector/0.16.1 \
    crate://crates.io/rustls-native-certs/0.5.0 \
    crate://crates.io/rustls-native-certs/0.6.2 \
    crate://crates.io/rustls-pemfile/1.0.0 \
    crate://crates.io/rustls/0.19.1 \
    crate://crates.io/rustls/0.20.6 \
    crate://crates.io/rustversion/1.0.8 \
    crate://crates.io/ryu/1.0.10 \
    crate://crates.io/safemem/0.3.3 \
    crate://crates.io/same-file/1.0.6 \
    crate://crates.io/schannel/0.1.20 \
    crate://crates.io/scheduled-thread-pool/0.2.6 \
    crate://crates.io/scoped-tls/1.0.0 \
    crate://crates.io/scopeguard/1.1.0 \
    crate://crates.io/sct/0.6.1 \
    crate://crates.io/sct/0.7.0 \
    crate://crates.io/security-framework-sys/2.6.1 \
    crate://crates.io/security-framework/2.6.1 \
    crate://crates.io/semver/1.0.12 \
    crate://crates.io/serde-value/0.7.0 \
    crate://crates.io/serde/1.0.139 \
    crate://crates.io/serde_derive/1.0.139 \
    crate://crates.io/serde_json/1.0.82 \
    crate://crates.io/serde_path_to_error/0.1.7 \
    crate://crates.io/serde_regex/1.1.0 \
    crate://crates.io/serde_urlencoded/0.7.1 \
    crate://crates.io/serde_yaml/0.8.26 \
    crate://crates.io/sha-1/0.10.0 \
    crate://crates.io/sha-1/0.8.2 \
    crate://crates.io/sha-1/0.9.8 \
    crate://crates.io/sha1/0.10.1 \
    crate://crates.io/sha1/0.6.1 \
    crate://crates.io/sha1_smol/1.0.0 \
    crate://crates.io/sha2/0.10.2 \
    crate://crates.io/sha2/0.9.9 \
    crate://crates.io/sharded-slab/0.1.4 \
    crate://crates.io/shlex/1.1.0 \
    crate://crates.io/signal-hook-registry/1.4.0 \
    crate://crates.io/signal-hook/0.3.14 \
    crate://crates.io/similar/2.1.0 \
    crate://crates.io/simple_asn1/0.6.2 \
    crate://crates.io/siphasher/0.3.10 \
    crate://crates.io/slab/0.4.6 \
    crate://crates.io/sluice/0.5.5 \
    crate://crates.io/smallvec/1.9.0 \
    crate://crates.io/socket2/0.4.4 \
    crate://crates.io/spin/0.5.2 \
    crate://crates.io/spin/0.9.4 \
    crate://crates.io/stable_deref_trait/1.2.0 \
    crate://crates.io/string_cache/0.8.4 \
    crate://crates.io/strsim/0.10.0 \
    crate://crates.io/strsim/0.8.0 \
    crate://crates.io/subtle/2.4.1 \
    crate://crates.io/syn/1.0.98 \
    crate://crates.io/sync_wrapper/0.1.1 \
    crate://crates.io/tcp-stream/0.24.4 \
    crate://crates.io/tempfile/3.3.0 \
    crate://crates.io/term/0.7.0 \
    crate://crates.io/termcolor/1.1.3 \
    crate://crates.io/textwrap/0.11.0 \
    crate://crates.io/textwrap/0.15.0 \
    crate://crates.io/thiserror-impl/1.0.31 \
    crate://crates.io/thiserror/1.0.31 \
    crate://crates.io/thread_local/1.1.4 \
    crate://crates.io/time-macros/0.2.4 \
    crate://crates.io/time/0.1.44 \
    crate://crates.io/time/0.3.11 \
    crate://crates.io/tiny-keccak/2.0.2 \
    crate://crates.io/tinyvec/1.6.0 \
    crate://crates.io/tinyvec_macros/0.1.0 \
    crate://crates.io/tokio-executor-trait/2.1.0 \
    crate://crates.io/tokio-io-timeout/1.2.0 \
    crate://crates.io/tokio-macros/1.8.0 \
    crate://crates.io/tokio-native-tls/0.3.0 \
    crate://crates.io/tokio-reactor-trait/1.1.0 \
    crate://crates.io/tokio-rustls/0.22.0 \
    crate://crates.io/tokio-rustls/0.23.4 \
    crate://crates.io/tokio-stream/0.1.9 \
    crate://crates.io/tokio-tungstenite/0.15.0 \
    crate://crates.io/tokio-util/0.6.10 \
    crate://crates.io/tokio-util/0.7.3 \
    crate://crates.io/tokio/1.20.0 \
    crate://crates.io/toml/0.5.9 \
    crate://crates.io/tonic-build/0.7.2 \
    crate://crates.io/tonic-reflection/0.4.0 \
    crate://crates.io/tonic-web/0.3.0 \
    crate://crates.io/tonic/0.7.2 \
    crate://crates.io/tower-http/0.1.3 \
    crate://crates.io/tower-http/0.3.4 \
    crate://crates.io/tower-layer/0.3.1 \
    crate://crates.io/tower-service/0.3.2 \
    crate://crates.io/tower/0.4.13 \
    crate://crates.io/tracing-attributes/0.1.22 \
    crate://crates.io/tracing-core/0.1.28 \
    crate://crates.io/tracing-futures/0.2.5 \
    crate://crates.io/tracing-log/0.1.3 \
    crate://crates.io/tracing-serde/0.1.3 \
    crate://crates.io/tracing-subscriber/0.2.25 \
    crate://crates.io/tracing/0.1.35 \
    crate://crates.io/try-lock/0.2.3 \
    crate://crates.io/tungstenite/0.14.0 \
    crate://crates.io/twoway/0.1.8 \
    crate://crates.io/typenum/1.15.0 \
    crate://crates.io/ucd-trie/0.1.4 \
    crate://crates.io/unicase/2.6.0 \
    crate://crates.io/unicode-bidi/0.3.8 \
    crate://crates.io/unicode-ident/1.0.2 \
    crate://crates.io/unicode-normalization/0.1.21 \
    crate://crates.io/unicode-width/0.1.9 \
    crate://crates.io/unicode-xid/0.2.3 \
    crate://crates.io/untrusted/0.7.1 \
    crate://crates.io/url/2.2.2 \
    crate://crates.io/urlencoding/1.3.3 \
    crate://crates.io/urlencoding/2.1.0 \
    crate://crates.io/utf-8/0.7.6 \
    crate://crates.io/uuid/1.1.2 \
    crate://crates.io/validator/0.13.0 \
    crate://crates.io/validator_types/0.12.0 \
    crate://crates.io/valuable/0.1.0 \
    crate://crates.io/value-bag/1.0.0-alpha.9 \
    crate://crates.io/vcpkg/0.2.15 \
    crate://crates.io/vec_map/0.8.2 \
    crate://crates.io/version_check/0.9.4 \
    crate://crates.io/waker-fn/1.1.0 \
    crate://crates.io/walkdir/2.3.2 \
    crate://crates.io/want/0.3.0 \
    crate://crates.io/warp/0.3.2 \
    crate://crates.io/wasi/0.10.0+wasi-snapshot-preview1 \
    crate://crates.io/wasi/0.11.0+wasi-snapshot-preview1 \
    crate://crates.io/wasm-bindgen-backend/0.2.81 \
    crate://crates.io/wasm-bindgen-futures/0.4.31 \
    crate://crates.io/wasm-bindgen-macro-support/0.2.81 \
    crate://crates.io/wasm-bindgen-macro/0.2.81 \
    crate://crates.io/wasm-bindgen-shared/0.2.81 \
    crate://crates.io/wasm-bindgen/0.2.81 \
    crate://crates.io/web-sys/0.3.58 \
    crate://crates.io/webpki-roots/0.22.4 \
    crate://crates.io/webpki/0.21.4 \
    crate://crates.io/webpki/0.22.0 \
    crate://crates.io/wepoll-ffi/0.1.2 \
    crate://crates.io/which/4.2.5 \
    crate://crates.io/winapi-i686-pc-windows-gnu/0.4.0 \
    crate://crates.io/winapi-util/0.1.5 \
    crate://crates.io/winapi-x86_64-pc-windows-gnu/0.4.0 \
    crate://crates.io/winapi/0.3.9 \
    crate://crates.io/windows-sys/0.36.1 \
    crate://crates.io/windows_aarch64_msvc/0.36.1 \
    crate://crates.io/windows_i686_gnu/0.36.1 \
    crate://crates.io/windows_i686_msvc/0.36.1 \
    crate://crates.io/windows_x86_64_gnu/0.36.1 \
    crate://crates.io/windows_x86_64_msvc/0.36.1 \
    crate://crates.io/winreg/0.10.1 \
    crate://crates.io/xmlparser/0.13.3 \
    crate://crates.io/yaml-rust/0.4.5 \
    crate://crates.io/yasna/0.5.0 \
    crate://crates.io/zeroize/1.5.6 \
"



# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    file://MIT;md5=generateme \
"

SUMMARY = "ChirpStack is an open-source LoRaWAN(TM) Network Server"
HOMEPAGE = "https://www.chirpstack.io/"
LICENSE = "MIT"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include chirpstack-${PV}.inc
include chirpstack.inc
